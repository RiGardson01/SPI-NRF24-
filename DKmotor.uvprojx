# Keil uVision project DKmotor.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DKmotor +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Project;..\..\Lib\CMSIS\CM3\CoreSupport;..\..\Lib\STM32F10x_StdPeriph_Driver\inc;..\..\Lib\STM32F10x_StdPeriph_Driver\src;..\..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\keic
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group user
    ../: stm32f10x_it.c system_stm32f10x.c main.c
    ./: GPIO.c GPIO.h RCC.c RCC.h SPI.c main.h SPI.h NRF.c NRF.h TIM2.c TIM2.h ADC.h ADC1.c SPI1.c SPI1.h NRF_SPI1.c NRF_SPI1.h
